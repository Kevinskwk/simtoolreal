Commit message: Add Allen key grasp bank inspection viewer

File: assets/urdf/table_allen_compact.urdf (robot description, URDF)
Before this commit: robot allen_compact_table, 1 links, 0 joints
Links:
- link box: geometry collision box size=0.18 0.16 0.30; visual box size=0.18 0.16 0.30
